# Keil uVision project Project.uvproj, settings and files
target GPIO (MCS-51)
  device: MS51PC0AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x3FFF)  XRAM(0 - 0x3FF) CLOCK(24000000)
  output: Project +hex
  AfterMake: $K\C51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  link misc: CLASSES(CODE(C:0x0000-C:0x7EFF), CONST(C:0x0000-C:0x7EFF))
  group Source Group 1
    ./: WLC_Indicator_model.c GPIO_Config.c GPIO_Config.h Timer3_Int.c Timer3_Int.h WLC_Functions.c WLC_Functions.h ADC_inputs.c ADC_inputs.h TM1637.c TM1637.h PUTCHAR.c
  group Library
    ../../../../Library/StdDriver/src/: sys.c eeprom.c adc.c common.c delay.c uart.c
  group Startup
    ../../../../Library/Startup/KEIL/: STARTUP.A51
